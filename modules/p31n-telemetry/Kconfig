## modules/p31n-telemetry/Kconfig
```kconfig
config P31N_TELEMETRY
    bool "P31n physical key BLE telemetry"
    depends on ZMK_BLE && !ZMK_SPLIT
    default n
```
